PACKAGECONFIG:append:imxgpu3d = " egl glesv2"
PACKAGECONFIG:remove_imxgpu3d = "opengl"
